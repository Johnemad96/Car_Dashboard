LIBCAMERA_PIPELINES = "rpi/vc4,uvcvideo,simple"
